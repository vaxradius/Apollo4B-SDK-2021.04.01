# IAR project libam_bsp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; DSI_FREQ=AM_HAL_DSI_FREQ_TRIM_X20; DBI_WIDTH=AM_HAL_DSI_DBI_WIDTH_16; B_USE_DPHYPLL=false; AM_PART_APOLLO4B; DISP_CFG; DISP_TYPE=RM67162_DSI; NUM_LANES=1; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\utils; ..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\devices; ..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\mcu\apollo4b
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: libam_bsp.bin
  ILINK.IlinkOutputFile: libam_bsp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  group (top)
    ../: am_bsp.c am_bsp_pins.c
