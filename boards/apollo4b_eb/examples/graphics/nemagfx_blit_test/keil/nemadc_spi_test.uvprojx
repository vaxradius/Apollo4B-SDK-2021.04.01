# Keil uVision project nemadc_spi_test.uvprojx, settings and files
target nemadc_spi_test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.8
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemadc_spi_test
  AfterMake: fromelf --bin --output bin\nemadc_spi_test.bin bin\nemadc_spi_test.axf
  AfterMake: fromelf -cedrst --output bin\nemadc_spi_test.txt bin\nemadc_spi_test.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: AM_PACKAGE_BGA USE_TSI_MALLOC NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK AM_PART_APOLLO4B BAREMETAL PLATFORM=apollo4b_nemagfx LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib keil
  c include: ../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../utils;../../../../../../mcu/apollo4b;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../bsp;../src;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../devices;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo4b/hal;../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c main.c nemadc_spi_test.c nemagfx_blit_test_cases.c
  group ThinkSi_apollo4b_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group devices
    ../../../../../../devices/: am_devices_nemadc_rm67162.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/keil/bin/: lib_nema_apollo4b_nemagfx.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
