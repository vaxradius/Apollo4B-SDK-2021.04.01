# IAR project nemagfx_performance_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO4B; BAREMETAL; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; USE_TSI_MALLOC; PLATFORM=apollo4b_nemagfx; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\..\..\devices; ..\..\..\..\..\..; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\src; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_performance_test.bin
  ILINK.IlinkOutputFile: nemagfx_performance_test.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx\iar\bin\lib_nema_apollo4b_nemagfx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO4B; BAREMETAL; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; USE_TSI_MALLOC; PLATFORM=apollo4b_nemagfx; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib
  group (top)
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../src/: am_resources.c DejaVuSerif27pt4b.c main.c nemagfx_performance_test.c simhei16pt4b.c simhei18pt4b.c simhei26pt4b.c simhei27pt4b.c simhei36pt4b.c
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_mspi_psram_aps12808l.c am_devices_nemadc_rm67162.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ./: startup_iar.c
