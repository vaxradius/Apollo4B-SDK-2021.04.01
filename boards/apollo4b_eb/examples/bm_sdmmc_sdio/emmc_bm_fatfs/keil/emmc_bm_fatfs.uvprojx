# Keil uVision project emmc_bm_fatfs.uvprojx, settings and files
target emmc_bm_fatfs (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: emmc_bm_fatfs
  AfterMake: fromelf --bin --output bin\emmc_bm_fatfs.bin bin\emmc_bm_fatfs.axf
  AfterMake: fromelf -cedrst --output bin\emmc_bm_fatfs.txt bin\emmc_bm_fatfs.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_DEBUG_PRINTF AM_PART_APOLLO4B keil
  c include: ../../../../../../mcu/apollo4b/hal;../../../../../..;../../../../../../CMSIS/ARM/Include;../../../../../../utils;../../../../../../CMSIS/AmbiqMicro/Include;../src;../../../../bsp;../../../../../../mcu/apollo4b;../../../../../../devices;../../../../../../third_party/FatFs/source
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c emmc_bm_fatfs.c mmc_apollo4.c
  group FatFs_source
    ../../../../../../third_party/FatFs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group utils
    ../../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
