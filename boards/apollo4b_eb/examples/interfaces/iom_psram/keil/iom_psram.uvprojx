# Keil uVision project iom_psram.uvprojx, settings and files
target iom_psram (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: iom_psram
  AfterMake: fromelf --bin --output bin\iom_psram.bin bin\iom_psram.axf
  AfterMake: fromelf -cedrst --output bin\iom_psram.txt bin\iom_psram.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO4B APS6404L AM_PACKAGE_BGA keil
  c include: ../src;../../../../../../devices;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../bsp;../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo4b;../../../../../../utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c iom_psram.c
  group devices
    ../../../../../../devices/: am_devices_spipsram.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
